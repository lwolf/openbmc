IMAGE_INSTALL_append = " screen tmux strace pciutils "