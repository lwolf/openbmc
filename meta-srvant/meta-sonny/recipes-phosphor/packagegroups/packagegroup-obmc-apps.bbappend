RDEPENDS_${PN}-extras_append_sonny = " webui-vue"
