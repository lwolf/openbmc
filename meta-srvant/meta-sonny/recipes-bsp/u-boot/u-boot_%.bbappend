SRC_URI = "git://github.com/lwolf/u-boot;branch=v2020.10-srvant-openbmc"
SRCREV = "cbfabeeeb0b41530f58f2b62b3456d0a6ab650b0"
