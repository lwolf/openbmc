KBRANCH ?= "playground-5.8.17"
LINUX_VERSION ?= "5.8.17"

SRCREV="daf89a34f89aebe7179dd96a126bbdd4733afedc"

require linux-srvant.inc
